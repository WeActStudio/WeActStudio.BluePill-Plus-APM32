# Keil uVision project msc.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: APM32F103CB Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: msc +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APM32F10X_MD
  c include: ..\APM32F103\CMSIS\Include;..\APM32F103\Device\Geehy\APM32F10x\Include;..\APM32F103\APM32F10x_StdPeriphDriver\inc;..\APM32F103\USB_Device_Lib\Core_Device\Standard\inc;..\APM32F103\USB_Device_Lib\Driver\inc;..\APM32F103\USB_Device_Lib\Core_Device\Class\MSC\inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Src/: apm32f10x_int.c main.c systick.c board.c
  group AppMsc
    ../Src/: usb_bsp.c usbd_descriptor.c usbd_msc.c usbd_storage_disk.c
  group UsbMsc
    ../APM32F103/USB_Device_Lib/Core_Device/Class/MSC/src/: usbd_class_msc.c usbd_msc_bot.c usbd_msc_scsi.c
  group StdPeriphDriver
    ../APM32F103/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_emmc.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
  group Startup
    ../APM32F103/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_md.s
  group CMSIS
    ../APM32F103/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
  group UsbCore
    ../APM32F103/USB_Device_Lib/Core_Device/Standard/src/: usbd_core.c usbd_init.c usbd_interrupt.c usbd_stdReq.c
  group UsbDriver
    ../APM32F103/USB_Device_Lib/Driver/src/: drv_usb_device.c
